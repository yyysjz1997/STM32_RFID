# Keil uVision project RFID.uvproj, settings and files
target RFID (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RFID +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\OUTPUT;..\HARDWARE\RFID;..\HARDWARE\KEY;..\HARDWARE\LCD;..\SYSTEM\usart;..\HARDWARE;..\FATFS;..\FATFS\doc;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\OV7670;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\TPAD;..\HARDWARE\W25QXX;..\MALLOC;..\PICTURE;..\TEXT;..\HARDWARE\EXTI;..\USMART;..\HARDWARE\OV7725;..\ATK-ESP8266;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\HARDWARE\USART3;..\ATK-ESP8266;..\APP;..\HARDWARE\VS10XX
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/OUTPUT/: output.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/: timer.c stmflash.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
    ../HARDWARE/OV7670/: ov7670.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/USART3/: usart3.c
    ../APP/: mp3player.c
    ../HARDWARE/VS10XX/: vs10xx.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group ATK_WIFI
    ../ATK-ESP8266/: apsta.c common.c wifiap.c wifista.c
